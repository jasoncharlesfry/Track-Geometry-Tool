# Keil uVision project jcf2876_lab8.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: jcf2876_lab8
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Main.c Sensor.h PEC16.h VNC1L.h Menu.h EV3479.h PLL.c ST7735.c PLL.h ST7735.h tm4c123gh6pm.h startup.s Sensor.c PEC16.c VNC1L.c Menu.c EV3479.c UART.h UART.c I2C.h I2C.c Switch.c Switch.h PortBHandler.c FixedMath.c FixedMath.h
software components: CMSIS:CORE 5.4.0
